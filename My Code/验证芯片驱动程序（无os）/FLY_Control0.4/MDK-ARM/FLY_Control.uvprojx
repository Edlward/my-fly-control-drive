# Keil uVision project FLY_Control.uvprojx, settings and files
target FLY_Control (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: FLY_Control
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\FM25VXX;..\HARDWARE\MLX90393;..\HARDWARE\BMI088;..\HARDWARE\MPU9250;..\HARDWARE\STM32_SPI;..\HARDWARE\MS5611
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: usart.c gpio.c stm32f4xx_hal_msp.c main.c spi.c stm32f4xx_it.c
  group HARDWARE
    ../HARDWARE/MPU9250/: stm32f4_mpu9250.c
    ../HARDWARE/STM32_SPI/: STM32_SPI.c
    ../HARDWARE/MS5611/: stm32f4_ms5611.c
    ../HARDWARE/MLX90393/: mlx90393.c
    ../HARDWARE/BMI088/: bmi088.c bmi088_stm32.c bmi08a.c bmi08g.c
    ../HARDWARE/FM25VXX/: FM25V10.C
software components: CMSIS:CORE 5.1.2
