# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (6090000::V6.9::.\ARMCLANG)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=4 v6Lang=4 v6LangP=6 wLevel=3
  c define: STM32F427xx, USE_HAL_DRIVER,ARM_MATH_CM4,RT_USING_ARM_LIBC
  c include: .;.\rt-thread\include;.\applications;.\device;.\drivers;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_HAL_Driver\Inc;.\rt-thread\libcpu\arm\common;.\rt-thread\libcpu\arm\cortex-m4;.\rt-thread\components\drivers\include;.\rt-thread\components\drivers\include;.\rt-thread\components\drivers\include;.\rt-thread\components\finsh;.\applications\LIB;.\applications\common_include;.\rt-thread\components\drivers\spi;.\rt-thread\components\dfs\include;.\rt-thread\components\dfs\filesystems\devfs;.\rt-thread\components\dfs\filesystems\elmfat;.\rt-thread\components\libc\compilers\common;.\rt-thread\components\libc\compilers\armlibc;.\rt-thread\components\utilities\ulog;.\applications\modules\EKF;.\rt-thread\components\drivers\spi\sfud\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32_rom.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Applications
    applications/: main.c
    ./: rtconfig.h
    ./applications/: common.h
  group FCmanager
    ./applications/FCmanager/: ekf2.cpp ekf2.h sensor_manager.c
  group mavlink
    ./applications/LIB/MAVLINK/: mavlink_main.c
  group Uorb
    ./applications/LIB/uORB/: Publication.cpp Subscription.cpp uORB.cpp uORBHelper.cpp uORBRam.cpp uORBTest.cpp
  group Drivers
    drivers/: board.c stm32f4xx_it.c drv_gpio.c drv_usart.c
    ./drivers/: drv_spiflash.c drv_spi.c drv_usbd.c drv_pwm.c
  group Device
    ./device/: fm25vxx.c mpu9250.c bmi088.c bmi088acc.c bmi088gro.c sbus.c pwmout.c mlx90393.c ms5611.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ./rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c spi_flash_w25qxx.c
    ./rt-thread/components/drivers/misc/: rt_drv_pwm.c
    ./rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Lib
    ./applications/modules/EKF/: ekf.cpp estimator_interface.cpp ekf_helper.cpp airspeed_fusion.cpp control.cpp covariance.cpp drag_fusion.cpp gps_checks.cpp gps_yaw_fusion.cpp mag_fusion.cpp optflow_fusion.cpp sideslip_fusion.cpp terrain_estimator.cpp vel_pos_fusion.cpp
    ./applications/modules/Time/: delay.c
    ./rt-thread/components/utilities/ulog/: ulog.c
    ./rt-thread/components/utilities/ulog/backend/: console_be.c
    ./applications/LIB/mathlib/: mathlib.cpp
    ./applications/LIB/geo/: geo.cpp
    ./applications/LIB/geo_lookup/: geo_mag_declination.cpp
  group Topics
    ./applications/LIB/uORB/topics_sources/: actuator_armed.cpp actuator_controls.cpp actuator_direct.cpp actuator_outputs.cpp adc_report.cpp airspeed_orb.cpp att_pos_mocap.cpp battery_status.cpp camera_trigger.cpp collision_report.cpp commander_state.cpp control_state.cpp cpuload.cpp debug_key_value.cpp differential_pressure.cpp distance_sensor.cpp ekf2_innovations.cpp ekf2_replay.cpp ekf2_timestamps.cpp esc_report.cpp esc_status.cpp estimator_status.cpp fence.cpp fence_vertex.cpp filtered_bottom_flow.cpp follow_target_orb.cpp fw_pos_ctrl_status.cpp fw_virtual_attitude_setpoint.cpp fw_virtual_rates_setpoint.cpp geofence_result.cpp gps_dump.cpp gps_inject_data.cpp hil_sensor.cpp home_position.cpp input_rc.cpp led_control.cpp log_message.cpp manual_control_setpoint.cpp mavlink_log.cpp mc_att_ctrl_status.cpp mc_virtual_attitude_setpoint.cpp mc_virtual_rates_setpoint.cpp mission_orb.cpp mission_result.cpp mount_orientation.cpp multirotor_motor_limits.cpp offboard_control_mode.cpp optical_flow.cpp output_pwm.cpp parameter_update.cpp position_setpoint.cpp position_setpoint_triplet.cpp pwm_input.cpp qshell_req.cpp rc_channels.cpp rc_parameter_map.cpp safety.cpp satellite_info.cpp sensor_accel.cpp sensor_baro.cpp sensor_combined.cpp sensor_correction.cpp sensor_gyro.cpp sensor_mag.cpp sensor_preflight.cpp servorail_status.cpp subsystem_info.cpp system_power.cpp task_stack_info.cpp tecs_status.cpp telemetry_status.cpp test_motor.cpp time_offset.cpp transponder_report.cpp uavcan_parameter_request.cpp uavcan_parameter_value.cpp ulog_stream.cpp ulog_stream_ack.cpp uORBTopics.cpp vehicle_attitude.cpp vehicle_attitude_setpoint.cpp vehicle_command.cpp vehicle_command_ack.cpp vehicle_control_mode.cpp vehicle_force_setpoint.cpp vehicle_global_position.cpp vehicle_global_velocity_setpoint.cpp vehicle_gps_position.cpp vehicle_land_detected.cpp vehicle_local_position.cpp vehicle_local_position_setpoint.cpp vehicle_rates_setpoint.cpp vehicle_roi.cpp vehicle_status.cpp vehicle_status_flags.cpp vtol_vehicle_status.cpp wind_estimate.cpp
  group Fafts
    ./rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ./rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ./rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group Usb
    ./rt-thread/components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ./rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427xx.s
  group STM32F4xx_HAL_Driver
    Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Calibration
    ./applications/modules/Cali/: accel_calibration.c accel_calibration.h gyro_calibration.c gyro_calibration.h mag_calibration.c mag_calibration.h common_calibration.h common_calibration.cpp
  group Math
    ./applications/LIB/math/math/: matrix_alg.cpp
    ./applications/LIB/math/math/filter/: LowPassFilter2p.cpp LowPassFilter2pVector3f.cpp
  group libc
    ./rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ./rt-thread/components/libc/compilers/common/: gmtime_r.c
